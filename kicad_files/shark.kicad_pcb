# Repository AcheronProject/SharkPCB (continued)

## KiCad design kicadFiles/shark.kicad_pcb

Parts:
CA1: 10n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
CB1: 10n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
CESD1: 4.7n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
CRST1: 10u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
CRST2: 4.7n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
CSH1: 4.7n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
CSI1: 100n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
CSO1: 100n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
CUSB1: 4.7n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
CVB1, CVB2, CVB3: 100n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
CVB4: 1u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
CVB5: 10n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
CVB6: 4.7u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
CX1, CX2: 22p; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48: 1N4148; D_SOD-123
DESD1: 1N4007; D_SOD-123
DF1: RB060M-60TR; D_SOD-123
DLDO1: 1N4007; D_SOD-123
DRST1: 1N4148; D_SOD-123
F1: 1A; Fuse_0805_2012Metric_Pad1.15x1.40mm_HandSolder
H1, H2, H3, H4, H5, H6: MountingHole; MountingHole_2.5mm_Pad
J1: TYPE-C-31-M12_13; TYPE-C-31-M-12
J2, J3, J4: Conn_01x04_Male; 4pinHeader
J5: Conn_01x06_Male; male6pinHeader
L1: Logo; sharkLogoPlated
L2: LogoBack; skark
L3: OSHLogo; osh-logo
L4: BrazilianFlag; brazilFlag
L5: usFlag
L6: usFlag; acheronLong
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12, LED13, LED14, LED15, LED16, LED17, LED18, LED19, LED20, LED21, LED22, LED23, LED24, LED25, LED26, LED27, LED28, LED29, LED30, LED31, LED32, LED33, LED34, LED35, LED36, LED37, LED38, LED39, LED40, LED41, LED42, LED43, LED44, LED45, LED46, LED47, LED48, LED49, LED50, LED51: LED; thtLED
Q1: AO4406AL; SOIC-8
QRST1: DTC123J; SOT-23
RA1, RA2: 10k; R_1026
RB1, RB2: 10k; R_1026
RCC1: 5.1k; R_1026
RCC2: 5.1k; R_SMD_1026
RDM1: 22R; R_1026
RDP1: 22R; R_1026
RESD1: 1M; R_1026
RGB1, RGB2, RGB3, RGB4, RGB5, RGB6, RGB7, RGB8: WS2812B; LED_WS2812B
RL1, RL2, RL3, RL4, RL5, RL6, RL7, RL8, RL9, RL10, RL11, RL12, RL13, RL14, RL15, RL16, RL17, RL18, RL19, RL20, RL21, RL22, RL23, RL24, RL25, RL26, RL27, RL28, RL29, RL30, RL31, RL32, RL33, RL34, RL35, RL36, RL37, RL38, RL39, RL40, RL41, RL42, RL43, RL44, RL45, RL46, RL47, RL48: 360; R_1026
ROT1, ROT2: Rotary_Encoder_Switch; ALPS_EC11E
RPG1: 10k; R_1026
RPU1: 5.1k; R_1026
RRST1: 100k; R_1026
RSG1: 100; R_1026
RSH1: 1M; R_1026
SRST1: SW_Push; smdPushBtn
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20, SW21, SW22, SW23, SW24, SW25, SW26, SW27, SW28, SW29, SW30, SW31, SW32, SW33, SW34, SW35, SW36, SW37, SW38, SW39, SW40, SW41, SW42, SW43, SW44, SW45, SW46, SW47, SW48: MXSwitch; MX100
SW49, SW50, SW51: MXSwitch; MX200R
U1: STM32F303-LQFP48; LQFP-48_7x7mm_P0.5mm
U2: MCP1700-3302E_SOT23; SOT-23
U3: USBLC6-2SC6; SOT-23-6
Y1: 8MHz; Crystal_SMD_5032-4Pin_5.0x3.2mm

Connections (part):
3.3V: CSO1.2, CVB1.1, CVB2.2, CVB3.2, CVB4.1, CVB5.2, CVB6.1, DLDO1.2 (A), J5.6, RA2.2, RB2.2, SRST1.1, U1.1 (VBAT), U1.9 (VCC/VDDA/VREF+), U1.24 (VCC), U1.36 (VCC), U1.48 (VCC), U2.2 (VO)
5V: CSI1.2, DF1.1 (K), DLDO1.1 (K), F1.1, J2.1, RGB1.1 (VDD), RGB2.1 (VDD), RGB3.1 (VDD), RGB4.1 (VDD), RGB5.1 (VDD), RGB6.1 (VDD), RGB7.1 (VDD), RGB8.1 (VDD), RL1.1, RL2.1, RL3.1, RL4.1, RL5.1, RL6.1, RL7.1, RL8.1, RL9.1, RL10.1, RL11.1, RL12.1, RL13.1, RL14.1, RL15.1, RL16.1, RL17.1, RL18.1, RL19.1, RL20.1, RL21.1, RL22.1, RL23.1, RL24.1, RL25.1, RL26.1, RL27.1, RL28.1, RL29.1, RL30.1, RL31.1, RL32.1, RL33.1, RL34.1, RL35.1, RL36.1, RL37.1, RL38.1, RL39.1, RL40.1, RL41.1, RL42.1, RL43.1, RL44.1, RL45.1, RL46.1, RL47.1, RL48.1, U2.3 (VI)
BOOT0: CRST1.2, DRST1.1 (K), J5.3, RRST1.1, U1.44 (BOOT0)
CASE: DESD1.2 (A), H4.1
Col1: ROT1.S2, SW1.1 (Col), SW13.1 (Col), SW25.1 (Col), SW37.1 (Col), U1.2 (PC13)
Col2: SW2.1 (Col), SW14.1 (Col), SW26.1 (Col), SW38.1 (Col), U1.3 (PC14/OSC32_IN)
Col3: SW3.1 (Col), SW15.1 (Col), SW27.1 (Col), SW39.1 (Col), U1.4 (PC15/OSC32_OUT)
Col4: SW4.1 (Col), SW16.1 (Col), SW28.1 (Col), SW40.1 (Col), U1.10 (PA0)
Col5: SW5.1 (Col), SW17.1 (Col), SW29.1 (Col), SW41.1 (Col), SW49.1 (Col), U1.12 (PA2)
Col6: SW6.1 (Col), SW18.1 (Col), SW30.1 (Col), SW42.1 (Col), SW50.1 (Col), U1.13 (PA3)
Col7: SW7.1 (Col), SW19.1 (Col), SW31.1 (Col), SW43.1 (Col), SW51.1 (Col), U1.14 (DAC1-OUT1/PA4)
Col8: SW8.1 (Col), SW20.1 (Col), SW32.1 (Col), SW44.1 (Col), U1.15 (DAC1-OUT2/PA5)
Col9: SW9.1 (Col), SW21.1 (Col), SW33.1 (Col), SW45.1 (Col), U1.17 (PA7)
Col10: SW10.1 (Col), SW22.1 (Col), SW34.1 (Col), SW46.1 (Col), U1.11 (PA1)
Col11: SW11.1 (Col), SW23.1 (Col), SW35.1 (Col), SW47.1 (Col), U1.25 (PB12)
Col12: ROT2.S2, SW12.1 (Col), SW24.1 (Col), SW36.1 (Col), SW48.1 (Col), U1.19 (PB1)
D+: RDP1.1, U1.33 (PA12/USB_DP)
D+Bus: J1.A6 (D+), J1.B6 (D+), RPU1.2
D-: RDM1.1, U1.32 (PA11/USB_DM)
D-Bus: J1.A7 (D-), J1.B7 (D-)
EncA: RA1.2, RA2.1, ROT1.A, ROT2.A
EncB: RB1.2, RB2.1, ROT1.B, ROT2.B
EncOutA: CA1.2, RA1.1, U1.42 (I2C1_SCL/PB6)
EncOutB: CB1.2, RB1.1, U1.43 (I2C1_SDA/PB7)
EncS1: D37.2 (A), ROT1.S1, SW37.2 (Row)
EncS3: D48.2 (A), ROT2.S1, SW48.2 (Row)
Extra1: J3.1, U1.29 (PA8)
Extra2: J3.2, U1.28 (PB15)
Extra3: J3.3, U1.27 (PB14)
Extra4: J3.4, U1.26 (PB13)
Extra5: J4.1, U1.39 (JTDO/TRACESWO/PB3)
Extra6: J4.2, U1.41 (PB5)
Extra7: J4.3, U1.45 (I2C1_SCL/PB8)
Extra8: J4.4, U1.46 (I2C1_SDA/PB9)
GND: CA1.1, CB1.1, CESD1.1, CRST1.1, CRST2.2, CSH1.1, CSI1.1, CSO1.1, CUSB1.1, CVB1.2, CVB2.1, CVB3.1, CVB4.2, CVB5.1, CVB6.2, CX1.2, CX2.2, DF1.2 (A), J1.A1 (GND), J1.B1 (GND), J2.4, J5.1, Q1.1, Q1.2, Q1.3, QRST1.2 (E), RCC1.1, RCC2.1, RESD1.2, RGB1.3 (VSS), RGB2.3 (VSS), RGB3.3 (VSS), RGB4.3 (VSS), RGB5.3 (VSS), RGB6.3 (VSS), RGB7.3 (VSS), RGB8.3 (VSS), ROT1.C, ROT2.C, RPG1.1, RRST1.2, RSH1.2, U1.8 (GND/VSSA/VREF-), U1.23 (GND), U1.35 (GND), U1.47 (GND), U2.1 (GND), Y1.2, Y1.4
LED_PWM: RSG1.2, U1.18 (PB0)
NRST: CRST2.1, J5.2, QRST1.3 (C), U1.7 (NRST)
unnamed: CESD1.2, DESD1.1 (K), RESD1.1
unnamed: CSH1.2, J1.S (SHIELD), RSH1.1
unnamed: D1.2 (A), SW1.2 (Row)
unnamed: D2.2 (A), SW2.2 (Row)
unnamed: D3.2 (A), SW3.2 (Row)
unnamed: D4.2 (A), SW4.2 (Row)
unnamed: D5.2 (A), SW5.2 (Row)
unnamed: D6.2 (A), SW6.2 (Row)
unnamed: D7.2 (A), SW7.2 (Row)
unnamed: D8.2 (A), SW8.2 (Row)
unnamed: D9.2 (A), SW9.2 (Row)
unnamed: D10.2 (A), SW10.2 (Row)
unnamed: D11.2 (A), SW11.2 (Row)
unnamed: D12.2 (A), SW12.2 (Row)
unnamed: D13.2 (A), SW13.2 (Row)
unnamed: D14.2 (A), SW14.2 (Row)
unnamed: D15.2 (A), SW15.2 (Row)
unnamed: D16.2 (A), SW16.2 (Row)
unnamed: D17.2 (A), SW17.2 (Row)
unnamed: D18.2 (A), SW18.2 (Row)
unnamed: D19.2 (A), SW19.2 (Row)
unnamed: D20.2 (A), SW20.2 (Row)
unnamed: D21.2 (A), SW21.2 (Row)
unnamed: D22.2 (A), SW22.2 (Row)
unnamed: D23.2 (A), SW23.2 (Row)
unnamed: D24.2 (A), SW24.2 (Row)
unnamed: D25.2 (A), SW25.2 (Row)
unnamed: D26.2 (A), SW26.2 (Row)
unnamed: D27.2 (A), SW27.2 (Row)
unnamed: D28.2 (A), SW28.2 (Row)
unnamed: D29.2 (A), SW29.2 (Row)
unnamed: D30.2 (A), SW30.2 (Row)
unnamed: D31.2 (A), SW31.2 (Row)
unnamed: D32.2 (A), SW32.2 (Row)
unnamed: D33.2 (A), SW33.2 (Row)
unnamed: D34.2 (A), SW34.2 (Row)
unnamed: D35.2 (A), SW35.2 (Row)
unnamed: D36.2 (A), SW36.2 (Row)
unnamed: D38.2 (A), SW38.2 (Row)
unnamed: D39.2 (A), SW39.2 (Row)
unnamed: D40.2 (A), SW40.2 (Row)
unnamed: D41.2 (A), SW41.2 (Row), SW49.2 (Row)
unnamed: D42.2 (A), SW42.2 (Row), SW50.2 (Row)
unnamed: D43.2 (A), SW43.2 (Row), SW51.2 (Row)
unnamed: D44.2 (A), SW44.2 (Row)
unnamed: D45.2 (A), SW45.2 (Row)
unnamed: D46.2 (A), SW46.2 (Row)
unnamed: D47.2 (A), SW47.2 (Row)
unnamed: DRST1.2 (A), QRST1.1 (B), SRST1.2
unnamed: J1.A5 (CC1), RCC1.2
unnamed: J1.B5 (CC2), RCC2.2
unnamed: LED1.A, RL1.2
unnamed: LED1.K, LED2.K, LED3.K, LED4.K, LED5.K, LED6.K, LED7.K, LED8.K, LED9.K, LED10.K, LED11.K, LED12.K, LED13.K, LED14.K, LED15.K, LED16.K, LED17.K, LED18.K, LED19.K, LED20.K, LED21.K, LED22.K, LED23.K, LED24.K, LED25.K, LED26.K, LED27.K, LED28.K, LED29.K, LED30.K, LED31.K, LED32.K, LED33.K, LED34.K, LED35.K, LED36.K, LED37.K, LED38.K, LED39.K, LED40.K, LED41.K, LED42.K, LED43.K, LED44.K, LED45.K, LED46.K, LED47.K, LED48.K, LED49.K, LED50.K, LED51.K, Q1.5 (D), Q1.6, Q1.7, Q1.8
unnamed: LED2.A, RL2.2
unnamed: LED3.A, RL3.2
unnamed: LED4.A, RL4.2
unnamed: LED5.A, RL5.2
unnamed: LED6.A, RL6.2
unnamed: LED7.A, RL7.2
unnamed: LED8.A, RL8.2
unnamed: LED9.A, RL9.2
unnamed: LED10.A, RL10.2
unnamed: LED11.A, RL11.2
unnamed: LED12.A, RL12.2
unnamed: LED13.A, RL13.2
unnamed: LED14.A, RL14.2
unnamed: LED15.A, RL15.2
unnamed: LED16.A, RL16.2
unnamed: LED17.A, RL17.2
unnamed: LED18.A, RL18.2
unnamed: LED19.A, RL19.2
unnamed: LED20.A, RL20.2
unnamed: LED21.A, RL21.2
unnamed: LED22.A, RL22.2
unnamed: LED23.A, RL23.2
unnamed: LED24.A, RL24.2
unnamed: LED25.A, RL25.2
unnamed: LED26.A, RL26.2
unnamed: LED27.A, RL27.2
unnamed: LED28.A, RL28.2
unnamed: LED29.A, RL29.2
unnamed: LED30.A, RL30.2
unnamed: LED31.A, RL31.2
unnamed: LED32.A, RL32.2
unnamed: LED33.A, RL33.2
unnamed: LED34.A, RL34.2
unnamed: LED35.A, RL35.2
unnamed: LED36.A, RL36.2
unnamed: LED37.A, RL37.2
unnamed: LED38.A, RL38.2
unnamed: LED39.A, RL39.2
unnamed: LED40.A, RL40.2
unnamed: LED41.A, LED49.A, RL41.2
unnamed: LED42.A, LED50.A, RL42.2
unnamed: LED43.A, LED51.A, RL43.2
unnamed: LED44.A, RL44.2
unnamed: LED45.A, RL45.2
unnamed: LED46.A, RL46.2
unnamed: LED47.A, RL47.2
unnamed: LED48.A, RL48.2
unnamed: Q1.4 (G), RPG1.2, RSG1.1
unnamed: RGB1.2 (DOUT), RGB2.4 (DIN)
unnamed: RGB2.2 (DOUT), RGB3.4 (DIN)
unnamed: RGB3.2 (DOUT), RGB4.4 (DIN)
unnamed: RGB5.2 (DOUT), RGB6.4 (DIN)
unnamed: RGB6.2 (DOUT), RGB7.4 (DIN)
unnamed: RGB7.2 (DOUT), RGB8.4 (DIN)
RGB_PWM: RGB1.4 (DIN), RGB5.4 (DIN), U1.16 (PA6)
Row1: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), U1.40 (JNTRST/PB4)
Row2: D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), U1.38 (I2C1_SCL/JTDI/PA15)
Row3: D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), U1.21 (PB10)
Row4: D37.1 (K), D38.1 (K), D39.1 (K), D40.1 (K), D41.1 (K), D42.1 (K), D43.1 (K), D44.1 (K), D45.1 (K), D46.1 (K), D47.1 (K), D48.1 (K), U1.20 (PB2)
SCL: J2.3, U1.30 (I2C2_SCL/PA9)
SDA: J2.2, U1.31 (I2C2_SDA/PA10)
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
Notes on the sheet:
Switch matrix
ESD inrush Protection
Data ESD Protection
Polyfuse PPTC RTC
RD for Resistor - Data CD for Capacitor - Data
I2C Connector
Shield net
Switch LED matrix
RGB
Serial programming
Encoder nets
Extra MCU pins
Logos and flags
USB Connector
Power supply and protection circuit
Hard reset circuit
Mounting holes
RSH for Resistor - Shield CSH for Capacitor - Shield RCC for Resistor - CC pin RPU for Resistor - Pull Up
MCU and crystal
RSG for Resistor - Serial to Gate RPG for Resistor - Parallel to Gate
CSI for Capacitor - Source Input CSO for Capacitor - Souce Output

Board: 2 copper layers, 225.6 x 74.6 mm, 268 parts (51 on the bottom side), 156 nets.
