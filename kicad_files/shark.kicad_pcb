# Repository AcheronProject/SharkPCB

File README.md:

# Acheron SharkPCB

The SharkPCB is a 40% ortho-layout PCB conceived as an alternative 40% ortho keyboard that could be easily built and sold in difficult-to-reach markets like the Brazilian market.

Go to the [Acheron Docs](http://acheronproject.com/pcbs/shark/shark/) for the SharkPCB documentation.

## KiCad design kicad_files/shark.kicad_pcb

Schematic: shark.kicad_sch, Noxary X60

Parts:
C1: 100n; C_0402_1005Metric
C2, C3, C4, C10, C12, C14, C18, C19: 100n; C_0402_1005Metric; Manufacturer Part Number CL05B104KB54PNC
C5: 10u; CP_EIA-3216-10_Kemet-I_Pad1.58x1.35mm_HandSolder; Manufacturer Part Number TAJA106K016RNJ
C6, C7: 15p; C_0402_1005Metric; Manufacturer Part Number 0402CG150J500NT
C8, C11: 4.7u; C_0402_1005Metric; Manufacturer Part Number CL05A475MP5NRNC
C9, C17: 10n; C_0402_1005Metric; Manufacturer Part Number CL05B103KB5NNNC
C13: 10u; C_0402_1005Metric; Manufacturer Part Number CL05A106MQ5NUNC
C15, C16, C20: 1u; C_0805_2012Metric; Manufacturer Part Number 0805B105K500NT
C21, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C32, C33, C34, C35, C36, C37, C38, C39, C40, C41, C42, C43, C44, C45, C46, C47, C48, C49, C50, C51, C52, C53: 100n; C_0805_2012Metric; Manufacturer Part Number CL21B104KCFNNNE
D1, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, D67, D68, D69, D70, D71, D72, D73, D74, D75, D76, D77, D78, D79, D80, D81, D82, D83, D84: 1N4148W; D_SOD-123; Manufacturer Part Number 1N4148W
D2: B5819W-SL; D_SOD-123; Manufacturer Part Number B5819W-SL
D3: SMF6.0A; D_SOD-123; Manufacturer Part Number SMF6.0A
D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D31, D32, D33, D34, D35, D36: WS2812C-2020; LED_WS2812_2020; Manufacturer Part Number WS2812C-2020
D21, D22, D23, D24, D25, D26, D27, D28, D29, D30: WS2812C-2020; LED_WS2812_2020_uparrow; Manufacturer Part Number WS2812C-2020
F1: nSMD100-16V; Fuse_1206_3216Metric; Manufacturer Part Number nSMD100-16V
FB1, FB2: GZ2012D601TF; L_0805_2012Metric; Manufacturer Part Number GZ2012D601TF
GR1: Shark Huge Logo; skark_huge_logo
GR2, GR4, GR6, GR9: Warning; Warning_Sign_3.6x3.2mm
GR3: Grounding sign; Grounding_Sign_3.6x3.2mm
GR5: Shark plated logo; shark_logo_plated
GR7: Athena Label; athena_label_35x5.6
GR8: Acheron Logo; acheronLong
H1: DB_RGB_PASSTHROUGH_HOLE; rgb_daughterboard_notch_plated_8x4mm
H2, H3, H4, H5, H6: MountingHole; shark_3mm_tht_mountinghole
J1: TYPE-C-31-M12; TYPE-C-31-M-12; Manufacturer Part Number TYPE-C-31-M-12
J2, J3: SM04B-SRSS-TB(LF)(SN); SM04B-SRSS-TB(LF)(SN)_mounting-reliefs; Manufacturer Part Number SM04B-SRSS-TB(LF)(SN)
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12, LED13, LED14, LED15, LED16, LED17, LED18, LED19, LED20, LED21, LED22, LED23, LED24, LED25, LED26, LED27, LED28, LED29, LED30, LED31, LED32, LED33, LED34, LED35, LED36, LED37, LED38, LED39, LED40, LED41, LED42, LED43, LED44, LED45, LED46, LED47, LED48, LED49, LED50, LED51, LED52, LED53, LED54, LED55, LED56, LED57, LED58, LED59, LED60, LED61, LED62, LED63, LED64, LED65, LED66, LED67, LED68, LED69, LED70, LED71, LED72, LED73, LED74, LED75, LED76, LED77, LED78, LED79, LED80, LED81, LED82, LED83, LED84, LED85, LED86, LED87, LED88, LED89, LED90, LED91, LED92, LED93, LED94, LED95, LED96, LED97, LED98, LED99, LED100, LED101, LED102, LED103, LED104, LED105, LED106, LED107, LED108, LED109, LED110, LED111, LED112: LED; LED_THT_2.54mm
Q1, Q2, Q4, Q5: 2N7002; SOT-23; Manufacturer Part Number 2N7002
Q3: AO3401A; SOT-23; Manufacturer Part Number Alpha & Omega Semicon
R1, R2: 4.7k; R_0402_1005Metric; Manufacturer Part Number 0402WGF4701TCE
R3: 10k; R_0805_2012Metric
R4: 1.5k; R_0402_1005Metric; Manufacturer Part Number 0402WGF1501TCE
R5: 0R; R_0805_2012Metric
R6: 330k; R_0402_1005Metric; Manufacturer Part Number 0402WGF3303TCE
R7: 1M; R_0402_1005Metric; Manufacturer Part Number 0402WGF1004TCE
R8, R15, R18, R19, R35: 10k; R_0402_1005Metric; Manufacturer Part Number 0402WGF1002TCE
R9, R10, R11: 100R; R_0402_1005Metric; Manufacturer Part Number 0402WGF1000TCE
R12, R16: 5.1k; R_0402_1005Metric; Manufacturer Part Number 0402WGF5101TCE
R13, R14: 100k; R_0805_2012Metric; Manufacturer Part Number 0805W8F1003T5E
R17, R94: 10k; R_0805_2012Metric; Manufacturer Part Number 0402WGF1002TCE
R20, R21: 100; R_0402_1005Metric; Manufacturer Part Number 0402WGF1000TCE
R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32, R33, R34, R36, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46, R47, R48, R49, R50, R51, R52, R53, R54, R55, R56, R57, R58, R59, R60, R61, R62, R63, R64, R65, R66, R67, R68, R69, R70, R71, R72, R73, R74, R75, R76, R77, R78, R79, R80, R81, R82, R83, R84, R85, R86, R87, R88, R89, R91, R92, R93, R95, R96, R97, R98, R99, R100, R101, R102, R103, R104, R105, R106, R107, R108, R109, R110, R111, R112, R113, R114, R115, R116, R117, R118, R119: 1k; R_0805_2012Metric; Manufacturer Part Number 0805W8F1001T5E
R90: 100; R_0805_2012Metric; Manufacturer Part Number 0402WGF1000TCE
SW1: K2-1187SQ-A4SW-06; Manufacturer Part Number K2-1187SQ-A4SW-06
SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20, SW21, SW22, SW23, SW24, SW25, SW26, SW27, SW28, SW29, SW30, SW31, SW32, SW33, SW34, SW35, SW36, SW37, SW38, SW39, SW40, SW41, SW42, SW43, SW44, SW45, SW46, SW47, SW48, SW49: MX Switch; MX100
U1: BL24C256A-SFRC; TSSOP-8_4.4x3mm_P0.65mm; Manufacturer Part Number BL24C256A-SFRC
U2: STM32F411CEU6; STM_UFQFPN-48_LQFP-48-1EP_7x7mm_P0.5mm_HandSoldering_Therma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; Manufacturer Part Number STM32F411
U3: USBLC6-2SC6; SOT-23-6; Manufacturer Part Number USBLC6-2SC6
U4: AT24C256C-SSHL-T; SOIC-8; Manufacturer Part Number AT24C256C-SSHL-T
U5: SGM2007-3.3XN5/TR; SOT-23-5; Manufacturer Part Number SGM2007-3.3XN5/TR
U6: TXS0101DBVR; SOT-23-6; Manufacturer Part Number TXS0101DBVR
X1: ARM JTAG; PinHeader_2x5_P2.54mm_Vertical_Staggered
X2: USB_EXPOSED_PINS; PinHeader_1x4_P2.54mm_Vertical
X3: MountingHole; MountingHole_2.5mm_Pad
X4: RGB_PINS; PinHeader_1x3_staggered_P2.54mm_Vertical
Y1: TAXM8M4RFDCET2T; Crystal_SMD_3225-4Pin_3.2x2.5mm; Manufacturer Part Number TAXM8M4RFDCET2T

Connections:
3V3: C1.2, C2.2, C3.1, C4.1, C5.1, C8.2, C9.2, C10.1, C12.2, C16.1, C18.2, D2.2 (A), R1.2, R2.2, R4.2, R14.1, R18.1, SW1.1 (A), U1.8 (VCC), U2.1 (VBAT), U2.9 (VDDA/VREF+), U2.24 (VDD), U2.36 (VDD), U2.48 (VDD), U4.8 (VCC), U5.5 (OUT), U6.1 (VCCA), X1.7, X1.8
5V: C15.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, C41.1, C42.1, C43.1, C44.1, C45.1, C46.1, C47.1, C48.1, C49.1, C50.1, C51.1, C52.1, C53.1, D2.1 (K), D3.1 (K), D4.4 (VDD), D5.4 (VDD), D6.4 (VDD), D7.4 (VDD), D8.4 (VDD), D9.4 (VDD), D10.4 (VDD), D11.4 (VDD), D12.4 (VDD), D13.4 (VDD), D14.4 (VDD), D15.4 (VDD), D16.4 (VDD), D17.4 (VDD), D18.4 (VDD), D19.4 (VDD), D20.4 (VDD), D21.4 (VDD), D22.4 (VDD), D23.4 (VDD), D24.4 (VDD), D25.4 (VDD), D26.4 (VDD), D27.4 (VDD), D28.4 (VDD), D29.4 (VDD), D30.4 (VDD), D31.4 (VDD), D32.4 (VDD), D33.4 (VDD), D34.4 (VDD), D35.4 (VDD), D36.4 (VDD), F1.1, J2.1, J3.1, Q3.2 (S), R5.1, R13.1, R19.2, U5.1 (IN), U5.3 (EN)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
/PA9: R5.2, U2.30 (PA9/USB_FS_VBUS)
BOOT0: C13.1, R6.1, R7.1, R8.2, U2.44 (BOOT0), X1.5
C0: SW2.2, SW14.2, SW26.2, SW38.2
C1: SW3.2, SW15.2, SW27.2, SW39.2
C2: SW4.2, SW16.2, SW28.2, SW40.2
C3: SW5.2, SW17.2, SW29.2, SW41.2
C4: SW6.2, SW18.2, SW30.2, SW42.2
C5: SW7.2, SW19.2, SW31.2, SW43.2
C6: SW8.2, SW20.2, SW32.2, SW44.2
C7: SW9.2, SW21.2, SW33.2, SW45.2
C8: SW10.2, SW22.2, SW34.2, SW46.2
C9: SW11.2, SW23.2, SW35.2, SW47.2
C10: SW12.2, SW24.2, SW36.2, SW48.2
C11: SW13.2, SW25.2, SW37.2, SW49.2
CAPS_INDICATOR: R90.1, U2.19 (PB1)
D+: J2.3, R4.1, U2.33 (PA12/USB_FS_DP), U3.3 (I/O2), X2.3
D-: J2.2, U2.32 (PA11/USB_FS_DM), U3.1 (I/O1), X2.2
DBUS+: J1.A6 (D+), J1.B6 (D+), U3.4 (I/O2)
DBUS-: J1.A7 (D-), J1.B7 (D-), U3.6 (I/O1)
GND: C1.1, C2.1, C3.2, C4.2, C5.2, C6.2, C7.2, C8.1, C9.1, C10.2, C11.1, C12.1, C13.2, C14.2, C15.2, C16.2, C17.1, C18.1, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, D3.2 (A), D4.2 (VSS), D5.2 (VSS), D6.2 (VSS), D7.2 (VSS), D8.2 (VSS), D9.2 (VSS), D10.2 (VSS), D11.2 (VSS), D12.2 (VSS), D13.2 (VSS), D14.2 (VSS), D15.2 (VSS), D16.2 (VSS), D17.2 (VSS), D18.2 (VSS), D19.2 (VSS), D20.2 (VSS), D21.2 (VSS), D22.2 (VSS), D23.2 (VSS), D24.2 (VSS), D25.2 (VSS), D26.2 (VSS), D27.2 (VSS), D28.2 (VSS), D29.2 (VSS)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
GNDPWR: FB1.2, J1.S (SHIELD)
LED_PWM: R21.1, U2.16 (PA6)
NRST: C14.1, R10.2, U2.7 (NRST), X1.9
unnamed: C11.2, U2.22 (VCAP_1)
unnamed: C17.2, U5.4 (BP/FB)
unnamed: D1.1 (K), R6.2
unnamed: D1.2 (A), R11.2, SW1.2 (B)
unnamed: D4.1 (DOUT), D5.3 (DIN)
unnamed: D5.1 (DOUT), D6.3 (DIN)
unnamed: D6.1 (DOUT), D7.3 (DIN)
unnamed: D7.1 (DOUT), D8.3 (DIN)
unnamed: D8.1 (DOUT), D9.3 (DIN)
unnamed: D10.1 (DOUT), D11.3 (DIN)
unnamed: D9.1 (DOUT), D10.3 (DIN)
unnamed: D11.1 (DOUT), D12.3 (DIN)
unnamed: D12.1 (DOUT), D13.3 (DIN)
unnamed: D13.1 (DOUT), D14.3 (DIN)
unnamed: D14.1 (DOUT), D15.3 (DIN)
unnamed: D15.1 (DOUT), D16.3 (DIN)
unnamed: D16.1 (DOUT), D17.3 (DIN)
unnamed: D17.1 (DOUT), D18.3 (DIN)
unnamed: D18.1 (DOUT), D19.3 (DIN)
unnamed: D19.1 (DOUT), D20.3 (DIN)
unnamed: D20.1 (DOUT), D21.3 (DIN)
unnamed: D21.1 (DOUT), D22.3 (DIN)
unnamed: D22.1 (DOUT), D23.3 (DIN)
unnamed: D23.1 (DOUT), D24.3 (DIN)
unnamed: D24.1 (DOUT), D25.3 (DIN)
unnamed: D25.1 (DOUT), D26.3 (DIN)
unnamed: D26.1 (DOUT), D27.3 (DIN)
unnamed: D27.1 (DOUT), D28.3 (DIN)
unnamed: D28.1 (DOUT), D29.3 (DIN)
unnamed: D29.1 (DOUT), D30.3 (DIN)
unnamed: D30.1 (DOUT), D31.3 (DIN)
unnamed: D31.1 (DOUT), D32.3 (DIN)
unnamed: D32.1 (DOUT), D33.3 (DIN)
unnamed: D33.1 (DOUT), D34.3 (DIN)
unnamed: D34.1 (DOUT), D35.3 (DIN)
unnamed: D35.1 (DOUT), D36.3 (DIN)
unnamed: D37.2 (A), SW2.1
unnamed: D38.2 (A), SW3.1
unnamed: D39.2 (A), SW4.1
unnamed: D40.2 (A), SW5.1
unnamed: D41.2 (A), SW6.1
unnamed: D42.2 (A), SW7.1
unnamed: D43.2 (A), SW8.1
unnamed: D44.2 (A), SW9.1
unnamed: D45.2 (A), SW10.1
unnamed: D46.2 (A), SW11.1
unnamed: D47.2 (A), SW12.1
unnamed: D48.2 (A), SW13.1
unnamed: D49.1 (K), D50.1 (K), D51.1 (K), D52.1 (K), D53.1 (K), D54.1 (K), D55.1 (K), D56.1 (K), D57.1 (K), D58.1 (K), D59.1 (K), D60.1 (K)
unnamed: D49.2 (A), SW14.1
unnamed: D50.2 (A), SW15.1
unnamed: D51.2 (A), SW16.1
unnamed: D52.2 (A), SW17.1
unnamed: D53.2 (A), SW18.1
unnamed: D54.2 (A), SW19.1
unnamed: D55.2 (A), SW20.1
unnamed: D56.2 (A), SW21.1
unnamed: D57.2 (A), SW22.1
unnamed: D58.2 (A), SW23.1
unnamed: D59.2 (A), SW24.1
unnamed: D60.2 (A), SW25.1
unnamed: D61.1 (K), D62.1 (K), D63.1 (K), D64.1 (K), D65.1 (K), D66.1 (K), D67.1 (K), D68.1 (K), D69.1 (K), D70.1 (K), D71.1 (K), D72.1 (K)
unnamed: D61.2 (A), SW26.1
unnamed: D62.2 (A), SW27.1
unnamed: D63.2 (A), SW28.1
unnamed: D64.2 (A), SW29.1
unnamed: D65.2 (A), SW30.1
unnamed: D66.2 (A), SW31.1
unnamed: D67.2 (A), SW32.1
unnamed: D68.2 (A), SW33.1
unnamed: D69.2 (A), SW34.1
unnamed: D70.2 (A), SW35.1
unnamed: D71.2 (A), SW36.1
unnamed: D72.2 (A), SW37.1
unnamed: D73.1 (K), D74.1 (K), D75.1 (K), D76.1 (K), D77.1 (K), D78.1 (K), D79.1 (K), D80.1 (K), D81.1 (K), D82.1 (K), D83.1 (K), D84.1 (K)
unnamed: D73.2 (A), SW38.1
unnamed: D74.2 (A), SW39.1
unnamed: D75.2 (A), SW40.1
unnamed: D76.2 (A), SW41.1
unnamed: D77.2 (A), SW42.1
unnamed: D78.2 (A), SW43.1
unnamed: D79.2 (A), SW44.1
unnamed: D80.2 (A), SW45.1
unnamed: D81.2 (A), SW46.1
unnamed: D82.2 (A), SW47.1
unnamed: D83.2 (A), SW48.1
unnamed: D84.2 (A), SW49.1
unnamed: FB2.1, X3.1
unnamed: J1.A5 (CC1), R12.2
unnamed: J1.B5 (CC2), R16.1
unnamed: LED1.A, LED2.A, LED3.A, LED4.A, LED26.A, LED27.A, LED28.A, LED45.A, LED46.A, LED47.A, LED48.A, LED63.A, LED64.A, LED65.A, LED66.A, LED67.A, LED78.A, LED79.A, LED80.A, LED81.A, LED82.A, LED83.A, LED84.A, LED85.A, LED86.A, LED87.A, LED88.A, LED89.A, LED90.A, LED91.A, LED95.A, Q3.3 (D), R22.1, R23.1, R24.1, R25.2, R26.2, R27.1, R28.1, R29.1, R30.1, R31.1, R32.1, R33.1, R34.1, R40.1, R41.1, R42.1, R43.1, R44.1, R45.1, R46.1, R47.1, R48.1, R49.1, R50.1, R51.1, R52.1, R53.1, R54.1, R58.1, R59.1, R60.1, R61.1, R62.1, R63.1, R64.1, R65.1, R66.1, R67.1, R68.1, R69.1, R70.1, R71.1, R76.1, R77.1, R78.1, R79.1, R80.1, R81.1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
unnamed: LED1.K, R36.1
unnamed: LED2.K, R37.1
unnamed: LED3.K, R39.1
unnamed: LED4.K, R38.1
unnamed: LED5.A, R22.2
unnamed: LED6.A, R23.2
unnamed: LED7.A, LED8.A, R24.2
unnamed: LED9.A, LED10.A, R25.1
unnamed: LED11.A, LED12.A, R26.1
unnamed: LED13.A, LED14.A, R27.2
unnamed: LED15.A, R28.2
unnamed: LED16.A, R29.2
unnamed: LED17.A, R30.2
unnamed: LED18.A, LED19.A, R31.2
unnamed: LED20.A, LED21.A, R32.2
unnamed: LED22.A, LED23.A, R33.2
unnamed: LED24.A, LED25.A, R34.2
unnamed: LED26.K, R55.1
unnamed: LED27.K, R56.1
unnamed: LED28.K, R57.1
unnamed: LED29.A, R40.2
unnamed: LED30.A, R41.2
unnamed: LED31.A, R42.2
unnamed: LED32.A, R43.2
unnamed: LED33.A, R44.2
unnamed: LED34.A, R45.2
unnamed: LED35.A, R46.2
unnamed: LED36.A, R47.2
unnamed: LED37.A, R48.2
unnamed: LED38.A, R49.2
unnamed: LED39.A, R50.2
unnamed: LED40.A, R51.2
unnamed: LED41.A, R52.2
unnamed: LED42.A, R53.2
unnamed: LED43.A, LED44.A, R54.2
unnamed: LED45.K, R75.1
unnamed: LED46.K, R72.1
unnamed: LED47.K, R73.1
unnamed: LED48.K, R74.1
unnamed: LED49.A, R58.2
unnamed: LED50.A, R59.2
unnamed: LED51.A, R60.2
unnamed: LED52.A, R61.2
unnamed: LED53.A, R62.2
unnamed: LED54.A, R63.2
unnamed: LED55.A, R64.2
unnamed: LED56.A, R65.2
unnamed: LED57.A, R66.2
unnamed: LED58.A, R67.2
unnamed: LED59.A, R68.2
unnamed: LED60.A, R69.2
unnamed: LED61.A, R70.2
unnamed: LED62.A, R71.2
unnamed: LED63.K, R85.1
unnamed: LED64.K, R86.1
unnamed: LED65.K, R87.1
unnamed: LED66.K, R88.1
unnamed: LED67.K, R89.1
unnamed: LED68.A, LED69.A, R76.2
unnamed: LED68.K, LED69.K, Q5.3 (D)
unnamed: LED70.A, R77.2
unnamed: LED71.A, R78.2
unnamed: LED72.A, R79.2
unnamed: LED73.A, R80.2
unnamed: LED74.A, R81.2
unnamed: LED75.A, R82.2
unnamed: LED76.A, R83.2
unnamed: LED77.A, R84.2
unnamed: LED78.K, R95.1
unnamed: LED79.K, R96.1
unnamed: LED80.K, R97.1
unnamed: LED81.K, R98.1
unnamed: LED82.K, R99.1
unnamed: LED83.K, R108.1
unnamed: LED84.K, R100.1
unnamed: LED85.K, R101.1
unnamed: LED86.K, R102.1
unnamed: LED87.K, R103.1
unnamed: LED88.K, R104.1
unnamed: LED89.K, R105.1
unnamed: LED90.K, R106.1
unnamed: LED91.K, R107.1
unnamed: LED92.A, R91.2
unnamed: LED93.A, R92.2
unnamed: LED94.A, R93.2
unnamed: LED95.K, R119.1
unnamed: LED96.A, LED97.A, R109.2
unnamed: LED98.A, LED99.A, R110.2
unnamed: LED100.A, LED101.A, R111.2
unnamed: LED102.A, LED103.A, R112.2
unnamed: LED104.A, R113.2
unnamed: LED105.A, LED106.A, R114.2
unnamed: LED107.A, LED108.A, R115.2
unnamed: LED109.A, LED110.A, R116.2
unnamed: LED111.A, R117.2
unnamed: LED112.A, R118.2
unnamed: Q1.1 (G), R9.2
unnamed: Q1.3 (D), R8.1
unnamed: Q2.1 (G), R11.1, R15.2
unnamed: Q2.3 (D), R9.1, R10.1
unnamed: Q3.1 (G), R20.2
unnamed: Q4.1 (G), R21.2, R35.2
unnamed: Q4.3 (D), R19.1, R20.1
unnamed: Q5.1 (G), R90.2, R94.2
unnamed: R18.2, U6.5 (OE)
PB2/BOOT1: R3.1, R17.1, U2.20 (PB2), X1.6
R0: D37.1 (K), D38.1 (K), D39.1 (K), D40.1 (K), D41.1 (K), D42.1 (K), D43.1 (K), D44.1 (K), D45.1 (K), D46.1 (K), D47.1 (K), D48.1 (K)
RGB_3V3: U2.28 (PB15/SPI2_MOSI), U6.3 (A)
RGB_5V_DB: D36.1 (DOUT), J3.3, X4.2
RGB_5V_MAIN: D4.3 (DIN), U6.4 (B)
SCL: R2.1, U1.6 (SCL), U2.42 (PB6/I2C1_SCL), U4.6 (SCL)
SDA: R1.1, U1.5 (SDA), U2.43 (PB7/I2C1_SDA), U4.5 (SDA)
SWCLK: U2.37 (PA14/SWCLK), X1.2
SWDIO: U2.34 (PA12/SWDIO), X1.1
VBUS: F1.2, J1.A4 (VBUS), J1.B4 (VBUS), U3.5 (VBUS)
XTAL_IN: C7.1, U2.5 (PH0_OSCIN), Y1.3
XTAL_OUT: C6.1, U2.6 (PH1_OSCOUT), Y1.1

Notes on the sheet:
3V3
EEPROM
Spooky pin (*)
RGB UNDERGLOW
(*) "Spooky pins": on STM32F4x1, pins A9 and B2 cannot be used for switch matrix: - A9 is meant to be used as a VBUS sensing. It has a undocumented internal pulldown resistor; - B2 is used as BOOT1 during bootup, so it needs an external pulldown for successful bootup
GRAPHICS
MCU
USB Connector
USB ESD
LED BACKLIGHT
HARD RESET
RGB STRIP
SWITCH MATRIX
(**) PA9 jumper: a solderable jumper used to tie PA9 to VBUS. It is disconnected by default, hence PA9 is left floating

Board: 2 copper layers, 225.6 x 74.6 mm, 441 parts (1 on the bottom side), 222 nets.
