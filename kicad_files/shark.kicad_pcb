# Repository AcheronProject/SharkPCB (continued)

## KiCad design ortho40.kicad_pcb

Parts:
C1, C2: 22p; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C3, C4, C5: 0.1u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C6: 4.7u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C8: 1u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D11, D12, D13, D14, D15, D16, D17, D18, D19, D21, D22, D23, D24, D25, D26, D27, D28, D29, D31, D32, D33, D34, D35, D36, D37, D38, D39, D41, D42, D43, D44, D45, D46, D47, D48, D49, D110, D111, D112, D210, D211, D212, D310, D311, D312, D410, D411, D412: 1N4148; D_DO-34_SOD68_P2.54mm_Vertical_AnodeUp
H1, H2, H3, H4, H5, H6: MountingHole; MountingHole_2.5mm_Pad
J1: USB_mini_micro_B; USB_Micro-B_GCT_USB3076-30-A
K2U1, K2U2, K2U3: KEYSW; Mx_Alps_200
K11, K12, K13, K14, K15, K16, K17, K18, K19, K21, K22, K23, K24, K25, K26, K27, K28, K29, K31, K32, K33, K34, K35, K36, K37, K38, K39, K41, K42, K43, K44, K45, K46, K47, K48, K49, K110, K111, K112, K210, K211, K212, K310, K311, K312, K410, K411, K412: KEYSW; Mx_Alps_100
R1, R2: 10k; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R3, R4: 22; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
SW1: SW_PUSH; SW_PUSH_6mm_H5mm
U1: ATMEGA32U4; LQFP-44_10x10mm_P0.8mm
X1: XTAL; Crystal_SMD_5032-2Pin_5.0x3.2mm_HandSoldering

Connections:
/Col1: K11.1, K21.1, K31.1, K41.1, U1.32 (PC7)
/Col2: K12.1, K22.1, K32.1, K42.1, U1.31 (PC6)
/Col3: K13.1, K23.1, K33.1, K43.1, U1.30 (PB6)
/Col4: K14.1, K24.1, K34.1, K44.1, U1.29 (PB5)
/Col5: K2U1.1, K15.1, K25.1, K35.1, K45.1, U1.28 (PB4)
/Col6: K2U2.1, K2U3.1, K16.1, K26.1, K36.1, K46.1, U1.27 (T0/PD7)
/Col7: K17.1, K27.1, K37.1, K47.1, U1.26 (T1/PD6)
/Col8: K18.1, K28.1, K38.1, K48.1, U1.25 (ICP1/PD4)
/Col9: K19.1, K29.1, K39.1, K49.1
/Col10: K110.1, K210.1, K310.1, K410.1
/Col11: K111.1, K211.1, K311.1, K411.1
/Col12: K112.1, K212.1, K312.1, K412.1
/D+: J1.3 (D+), R4.2
/D-: J1.2 (D-), R3.2
/RST: R1.1, SW1.2, U1.13 (~RESET)
/Row1: D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D110.1 (K), D111.1 (K), D112.1 (K), U1.22 (PD5/XCK1)
/Row2: D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D210.1 (K), D211.1 (K), D212.1 (K), U1.21 (PD3/TXD1)
/Row3: D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), D37.1 (K), D38.1 (K), D39.1 (K), D310.1 (K), D311.1 (K), D312.1 (K), U1.41 (PF0)
/Row4: D41.1 (K), D42.1 (K), D43.1 (K), D44.1 (K), D45.1 (K), D46.1 (K), D47.1 (K), D48.1 (K), D49.1 (K), D410.1 (K), D411.1 (K), D412.1 (K), U1.40 (PF1)
/XTAL1: C1.1, U1.16 (XTAL1), X1.1
/XTAL2: C2.1, U1.17 (XTAL2), X1.2
GND: C1.2, C2.2, C3.1, C4.1, C5.1, C6.1, C8.2, J1.5 (GND), J1.6 (SHIELD), R2.1, SW1.1, U1.5 (UGnd), U1.15 (GND), U1.23 (GND), U1.35 (GND), U1.43 (GND)
unnamed: C8.1, U1.6 (UCap)
unnamed: D11.2 (A), K11.2
unnamed: D12.2 (A), K12.2
unnamed: D13.2 (A), K13.2
unnamed: D14.2 (A), K14.2
unnamed: D15.2 (A), K15.2
unnamed: D16.2 (A), K16.2
unnamed: D17.2 (A), K17.2
unnamed: D18.2 (A), K18.2
unnamed: D19.2 (A), K19.2
unnamed: D21.2 (A), K21.2
unnamed: D22.2 (A), K22.2
unnamed: D23.2 (A), K23.2
unnamed: D24.2 (A), K24.2
unnamed: D25.2 (A), K25.2
unnamed: D26.2 (A), K26.2
unnamed: D27.2 (A), K27.2
unnamed: D28.2 (A), K28.2
unnamed: D29.2 (A), K29.2
unnamed: D31.2 (A), K31.2
unnamed: D32.2 (A), K32.2
unnamed: D33.2 (A), K33.2
unnamed: D34.2 (A), K34.2
unnamed: D35.2 (A), K35.2
unnamed: D36.2 (A), K36.2
unnamed: D37.2 (A), K37.2
unnamed: D38.2 (A), K38.2
unnamed: D39.2 (A), K39.2
unnamed: D41.2 (A), K41.2
unnamed: D42.2 (A), K42.2
unnamed: D43.2 (A), K43.2
unnamed: D44.2 (A), K44.2
unnamed: D45.2 (A), K2U1.2, K45.2
unnamed: D46.2 (A), K2U2.2, K2U3.2, K46.2
unnamed: D47.2 (A), K47.2
unnamed: D48.2 (A), K48.2
unnamed: D49.2 (A), K49.2
unnamed: D110.2 (A), K110.2
unnamed: D111.2 (A), K111.2
unnamed: D112.2 (A), K112.2
unnamed: D210.2 (A), K210.2
unnamed: D211.2 (A), K211.2
unnamed: D212.2 (A), K212.2
unnamed: D310.2 (A), K310.2
unnamed: D311.2 (A), K311.2
unnamed: D312.2 (A), K312.2
unnamed: D410.2 (A), K410.2
unnamed: D411.2 (A), K411.2
unnamed: D412.2 (A), K412.2
unnamed: R2.2, U1.33 (~HWB/PE2)
unnamed: R3.1, U1.3 (D-)
unnamed: R4.1, U1.4 (D+)
VCC: C3.2, C4.2, C5.2, C6.2, J1.1 (VUSB), R1.2, U1.2 (UVcc), U1.7 (VBus), U1.14 (VCC), U1.24 (AVCC), U1.34 (VCC), U1.44 (AVCC)

Board: 2 copper layers, 227.1 x 76.0 mm, 120 parts (0 on the bottom side), 75 nets.

## Commit log

2018-05-28 Create dev1
2018-11-17 Adding functional PCB
2018-11-17 Added Planck-compatible mounting holes
2018-11-17 Added support for full grid and 2x2U
2018-11-17 Added gerber files
2018-11-17 Added preview image
2018-11-17 Added plate file
2018-11-18 Added plate files
2018-11-18 Updated plate files
2018-11-18 Fixed problem with board outline
2018-11-18 Changed board size for Planck case compatibility
2018-11-18 Added plate gerber files
2018-11-19 Cleaned up unused files
2018-11-20 Added Shark illustration
2018-11-20 Updated board preview
2018-11-21 Added plate 2
2018-11-26 Added board SVG for case design
2018-11-28 Renamed files and removed old footprint libraries
2018-11-28 Edited PCB to use new footprints
2018-11-28 Placed footprints
2018-11-29 Added row and column traces, fixed some components positions
2018-11-29 Removed unused files
2018-12-04 Continued tracing
2018-12-15 Finished routing
2018-12-17 Fixed schematic, removed stitches
2018-12-17 Readded preview
2018-12-18 Started adding LEDs
2019-01-11 Progressed with routing
2019-01-11 Added logo
2019-01-11 Added updated preview
2019-01-13 Started switch to STM32F303 processor
2019-01-14 Began porting to STM32
2019-01-14 Solved issues with connector via placement
2019-01-15 Started rounting
2019-01-15 Continued routing
2019-01-21 Added better render to board preview
2019-01-25 Proceeded routing
2019-01-25 Changed to SMD changes
2019-01-26 Added photorealistic renders
2019-01-26 Fixed renders
2019-01-26 Updated preview
2019-01-26 Added animation
2019-01-29 Added Pirulen font to the logo
2019-01-29 Adde backrender to README preview
2019-02-04 Finished design. Thickening possible traces
2019-02-04 Finished design and added BOM
2019-02-09 Added BOM file that can be used in LCSC site
2019-02-09 Added BOM table to README
2019-02-10 Change CVBus4 package to 0402
2019-02-10 Added OSH logo
2019-02-14 Added US and BR flags, rounded corners
2019-02-14 Fixed README BOM table
2019-02-21 Added rotary encoder support
2019-02-21 Edited gerbers
2019-02-21 Fixed plate gerbers
2019-02-21 Updated renders
2019-02-26 Updated BOM with rotary encoder
2019-02-26 Updated README with FAQ
2019-02-28 Fixed little problem with edge cuts
2019-02-28 Testing spoiler feature on README.md
2019-02-28 Tagged ver 3.1.1 for pre-release
2019-02-28 Named the SharkPCB in its default Acheron naming
2019-03-01 Added LICENSE file
2019-03-11 Reorganized folders and begun V3.1.2
2019-03-11 Reorganized folders
2019-03-13 Added encoder position and moved push button
2019-03-13 Added I2C pins and hi-pro compatible plates
2019-03-13 Updated README and new release
2019-03-14 Chore: updated README
2019-03-14 Feature: base plate for skeleton build
2019-03-16 [Feature] Changed the I2C pins to a common pin header
2019-03-17 [Feature] Added header pins for the extra MCU pins
2019-03-17 [Maintenance] Started adding dimensions and minimal values documentation
2019-03-17 [Maintenance] Started making silkscreen characters bigger for readability
2019-03-17 [Maintenance] Added documentation and notes on the design
2019-03-18 [Feature] Added artworks
2019-03-19 [Fix] Fixed the mounting hole positioning in the hi-pro plates
2019-03-19 [Fix] Fixed the arrow and font problems in the artworks
2019-03-19 [Maintenance] Added hi and lo pro plates compatibility to the base plate
2019-03-19 [Fix] Used 3.3V for encoder VCC instead of 5V
2019-03-20 [Maintenance] Moved some SMD parts to the bottom layer to ensure no problems with switch mounting
2019-03-20 [Maintenance] Updated README
2019-03-21 [Fix] Removed inconsistencies in BOM and added correct gerber
2019-03-21 [Fix, Feature] Added frill file to PCB gerbers and added Shark logo to base plate
2019-03-21 [Feature] Added Shark logo to base plate
2019-03-21 [Fix] Updated README
2019-03-21 [Feature] Adde the Acheron Project logo
2019-03-25 [Update] Updated README
2019-03-25 [Update] Added pictures of prototypes to the repo as the imgur folder is about to break
2019-03-29 [Update] Artworks were scaled to A1 size
2019-03-30 [Feature] Added 3D STEP file to renders folder
2019-04-01 [Update] Updated universal hi-pro plate STEP file
2019-04-08 [Feature] Added preliminary case files[Feature] Added preliminary case files
2019-04-11 [Fix] Adjusted plate files to match the custom case
2019-04-11 [Update] Added embedded viewers for the cases
2019-04-15 [Fix] Adjusted base plate and made its shark logo plated
2019-04-23 Fix README.md Ackknowledgements username
2019-04-25 Fix section links
2019-04-28 [Feature] Started adding documentation with Sphinx
2019-04-28 [Update] Will be doing documentation on another branch
2019-04-28 [Update] First commit of the Acheron Docs
2019-04-28 [Update] Updated docs folders to accomodate sources on docsources
2019-04-28 [Update] Moved all documentation to the Acheron Project page
2019-05-02 [Update] Updated case files. The highShark stl file will be added in a future commit with git LFS
2019-05-02 [Update] Added the highShark stl file to git LFS
2019-05-02 [Update] Added the mechanical specifications file for the Low Shark case
2019-05-04 Updated tall case file, added tall case mechanical specs and added renders
2019-05-05 [Feature] Added DXF files for the plates
2019-05-07 [Update,Feature] Reorganized the renders folder and added renders of the high case
2019-05-07 [Fix] The DXF plate files did not have any screw holes
2019-05-10 [Fix] Fixed plates middle hole
2019-05-10 [Update] Enlarged the plate pegs holes in the PCB
2019-05-10 [Fix] Fixed problems with the cases
2019-05-10 Fixed plate problems
2019-05-10 [Update] Made USB cutout fillet radius 1.5 mm
2019-05-16 [Fix] The low Plate gerber files were corrupted
2019-05-20 [Update] Pre-release of version 3.2.0
2019-05-20 [Update] Pre-release of version 3.2.1
2019-05-20 [Update] Pre-release of version 3.2.1. Updated gerbers and bom.
2019-05-20 [Update] Updated README.
2019-05-21 [Update] Pre-release of version 3.2.2
2019-05-21 [Update] Made changes to routing
2019-05-21 [Update] Updated gerbers for V3.2.3
2019-05-22 V3.2.4
2019-05-27 Updated footprints according to Acheron Library changes
2019-06-19 [Update] USB connector label and revisited BOM
2019-06-21 [Update] V3.2.7 tag
2019-06-21 [Update] Fixed problem with trace spacing around ROT1 and the microprocessor
2019-07-02 [Fix, Update] Tagged ver. 3.2.8
2019-07-03 [Fix] Fixed low plate gerber files
2019-07-11 [Update] Renamed some nets and re-routed some traces related to the encoders for better understanding of the circuit and noice cancelling
2019-08-15 Added 3D model
    - Added 3D model of the PCB in the ./3D\ Model folder
2019-09-09 Change pins in footprint
    - The LED_PWM pin was changed to pin B7, which has PWM capability;
    - The RGB_LED pin was changed to B6, which has SPI capability;
    - Some col and row pins were change to accomodate those chamges;
2019-09-09 Implement schematic changes to PCB
    - The schematic changes done at the last commit were implemented to the PCB.
    - DRC is still pending.
2019-09-10 Changed LED/RGB pins and readjusted col and row
    - The LED_PWM pin was changed to B0 which has PWM capabilities;
    - RGB_PWM was changed to A6 which is SPI_MISO, being able to drive the WS2812 LEDs through SPI;
    - A row and a column had pins changed to accomodate for those changes.
2019-09-10 Added connector cutout to base plate
2019-09-10 Updated BOM and gerbers
2019-10-06 Make graphics dir, delete manu files
2019-10-07 [Update] Remove all non-PCB related files
2019-12-03 Fixing documentation URL
2019-12-10 Update README mention of Shark hardware repo
2020-04-17 Fix Shark documentation link
2020-08-23 First V4 commit
    - New F072 MCU
    - New RGB level translator
    - New LED switching circuit
    - RGB wired, columns wire, data pins wired
2020-08-28 Mounting holes, MCU, 3v3, grounding, LEDs
    - Introduced Wurth SMD mounting standoffs and case grounding through a ferite bead on one of the standoffs
    - Routed MCU with copper zones
    - Routed 3V3 LDO circuit
    - Routed first row with diodes and LEDs and LED resistors
    - Added zone cutout on ground copper fill under USB connector
    - Added USBC shield grounding through ferrite bead
2020-09-02 Routed second row
2020-09-03 Route 4th row, remove unusable LEDs, re-centered RGBs in 4th row
2021-11-15 Minor grammar corrections
2022-01-17 New KiCAD version, fix D+ pullup value
2022-01-17 Update PCB from schematic
2022-01-17 Remove old KiCAD version files
2022-01-17 Add warning to README
2022-01-17 Connect USB pullup to 3V3 on schematic
2022-01-29 New version started
2022-01-31 Start porting to Joker48 template
2022-02-01 Routing job
2022-02-02 More routing
2022-02-02 Finish routing
2022-02-04 Edit component metadata; prepare for releasee
2022-02-04 Add README
