File: kicadFiles/shark.sch (KiCad schematic (older format))
At the start: 264 parts, among them J1 USB_C_Receptacle, J2 Conn_01x04_Male, J3 Conn_01x04_Male, J4 Conn_01x04_Male, J5 Conn_01x06_Male, Q1 AO4406AL, SW1 MXSwitch, SW10 MXSwitch, SW11 MXSwitch, SW12 MXSwitch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

Commit message: V3.2.4
Parts:
- added CUSB1: 4.7n, Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder, symbol Device:C_Small
- added CVA1: 1u, Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder, symbol Device:C_Small
- added CVA2: 10n, Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder, symbol Device:C_Small
- added U3: USBLC6-2SC6, Package_TO_SOT_SMD:SOT-23-6, symbol Power_Protection:USBLC6-2SC6
- J1: symbol shark-rescue:USB_C_Receptacle-Connector-shark-rescue-shark-rescue -> shark-rescue:USB_C_Receptacle-Connector-shark-rescue-shark-rescue-shark-rescue
- renumbered CV1 to CVB1, CV2 to CVB2, CV3 to CVB3, CV4 to CVB4, CV5 to CVB5, RD+Up1 to RDPUp1
Connections:
- net 3.3V: now also CVA1.2, CVA2.2
- net 5V: no longer RDPUp1.1
- net GND: now also CUSB1.1, CVA1.1, CVA2.1, U3.2 (GND)
- net VBUS: now also RDPUp1.1
- net D+Bus: now reaches J1.A6 (D+), J1.B6 (D+), RDPUp1.2
- net D+Bus: now also U3.3 (IO2); no longer RD+1.2
- net D-Bus: now reaches J1.A7 (D-), J1.B7 (D-)
- net D-Bus: now also U3.1 (IO1); no longer RD-1.2
- new net: RD+1.2, U3.4 (IO2)
- new net: CUSB1.2, U3.5 (VBUS)
- new net: RD-1.2, U3.6 (IO1)
Other:
- note added: "Data ESD\nProtection"
- note added: "ESD inrush\nProtection"
- note removed: "ESD\nProtection"
- moved on the sheet: RD+1, RD-1
Changed lines of the file:
@@
 Sheet 1 1
 Title "SharkPCB"
-Date "2019-05-21"
-Rev "3.2.3"
+Date "2019-05-22"
+Rev "3.2.4"
 Comp "Gondolin Electronics"
 Comment1 ""
@@
 $EndComp
 Text Notes 18225 12825 0    100  Italic 20
-ESD\nProtection
+ESD inrush\nProtection
 $Comp
 L Mechanical:MountingHole L1
@@
 	16025 9850 16250 9850
 $Comp
-L shark-rescue:USB_C_Receptacle-Connector-shark-rescue-shark-rescue J1
+L shark-rescue:USB_C_Receptacle-Connector-shark-rescue-shark-rescue-shark-rescue J1
 U 1 1 5CC01BA3
 P 8625 10675
@@
 	0    -1   -1   0
 $EndComp
-Text GLabel 9750 10175 2    50   BiDi ~ 0
+Text GLabel 16300 12075 2    50   BiDi ~ 0
 D-
-Text GLabel 9750 10375 2    50   BiDi ~ 0
+Text GLabel 16300 13200 2    50   BiDi ~ 0
 D+
 Wire Wire Line
-	9225 10175 9300 10175
-Wire Wire Line
 	9225 10275 9300 10275
 Wire Wire Line
@@
 $EndComp
 Wire Wire Line
-	19175 3700 19125 3700
-Wire Wire Line
 	19125 3700 19125 3550
 Wire Wire Line
@@
 $EndComp
 $Comp
-L Device:R_Small RD-1
-U 1 1 5E5BA0B3
-P 9575 10175
-F 0 "RD-1" V 9500 10110 31  0000 L CNN
-F 1 "22R" V 9575 10125 31  0000 L CNN
-F 2 "Resistor_SMD:R_1206_3216Metric_Pad1.42x1.75mm_HandSolder" H 9575 10175 50  0001 C CNN
-F 3 "~" H 9575 10175 50  0001 C CNN
-	1    9575 10175
-	0    1    1    0
-$EndComp
-$Comp
 L Device:R_Small RD+1
 U 1 1 5E5BB8E0
-P 9575 10375
-F 0 "RD+1" V 9500 10310 31  0000 L CNN
-F 1 "22R" V 9575 10325 31  0000 L CNN
-F 2 "Resistor_SMD:R_1206_3216Metric_Pad1.42x1.75mm_HandSolder" H 9575 10375 50  0001 C CNN
-F 3 "~" H 9575 10375 50  0001 C CNN
-	1    9575 10375
+P 16150 13200
+F 0 "RD+1" V 16075 13135 31  0000 L CNN
+F 1 "22R" V 16150 13150 31  0000 L CNN
+F 2 "Resistor_SMD:R_1206_3216Metric_Pad1.42x1.75mm_HandSolder" H 16150 13200 50  0001 C CNN
+F 3 "~" H 16150 13200 50  0001 C CNN
+	1    16150 13200
 	0    1    1    0
 $EndComp
-Wire Wire Line
-	9675 10375 9750 10375
-Wire Wire Line
-	9750 10175 9675 10175
 $Comp
 L power:GND #PWR05
@@
 $EndComp
 $Comp
-L Device:R_Small RD+Up1
+L Device:R_Small RDPUp1
 U 1 1 5EA80DA8
 P 9575 10475
-F 0 "RD+Up1" V 9650 10380 31  0000 L CNN
+F 0 "RDPUp1" V 9650 10380 31  0000 L CNN
 F 1 "1.5k" V 9575 10425 31  0000 L CNN
 F 2 "Resistor_SMD:R_1206_3216Metric_Pad1.42x1.75mm_HandSolder" H 9575 10475 50  0001 C CNN
@@
 	9650 9875 9700 9875
 Wire Wire Line
-	9300 10175 9475 10175
-Connection ~ 9300 10175
-Wire Wire Line
 	9300 9875 9450 9875
 $Comp
-L Device:C_Small CV1
+L Device:C_Small CVB1
 U 1 1 5ED231C7
 P 19400 10200
-F 0 "CV1" H 19492 10231 31  0000 L CNN
+F 0 "CVB1" H 19492 10231 31  0000 L CNN
 F 1 "100n" H 19492 10169 31  0000 L CNN
 F 2 "Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder" H 19400 10200 50  0001 C CNN
@@
 $EndComp
 $Comp
-L Device:C_Small CV2
+L Device:C_Small CVB2
 U 1 1 5ED24D83
 P 19750 10200
-F 0 "CV2" H 19842 10231 31  0000 L CNN
+F 0 "CVB2" H 19842 10231 31  0000 L CNN
 F 1 "100n" H 19842 10169 31  0000 L CNN
 F 2 "Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder" H 19750 10200 50  0001 C CNN
@@
 $EndComp
 $Comp
-L Device:C_Small CV3
+L Device:C_Small CVB3
 U 1 1 5ED24FA7
 P 20100 10200
-F 0 "CV3" H 20192 10231 31  0000 L CNN
+F 0 "CVB3" H 20192 10231 31  0000 L CNN
 F 1 "100n" H 20192 10169 31  0000 L CNN
 F 2 "Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder" H 20100 10200 50  0001 C CNN
@@
 $EndComp
 $Comp
-L Device:C_Small CV4
+L Device:C_Small CVB4
 U 1 1 5ED251CF
 P 20450 10200
-F 0 "CV4" H 20542 10231 31  0000 L CNN
+F 0 "CVB4" H 20542 10231 31  0000 L CNN
 F 1 "1u" H 20542 10169 31  0000 L CNN
 F 2 "Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder" H 20450 10200 50  0001 C CNN
@@
 $EndComp
 $Comp
-L Device:C_Small CV5
+L Device:C_Small CVB5
 U 1 1 5ED253F3
 P 20800 10200
-F 0 "CV5" H 20892 10231 31  0000 L CNN
+F 0 "CVB5" H 20892 10231 31  0000 L CNN
 F 1 "4.7u" H 20892 10169 31  0000 L CNN
 F 2 "Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder" H 20800 10200 50  0001 C CNN
@@
 	9750 10475 9675 10475
 Text GLabel 9750 10475 2    50   Output ~ 0
-5V
+VBUS
 Text GLabel 16025 9775 1    50   Output ~ 0
 5V
@@
 Switch LED matrix
 Wire Notes Line width 20
-	18525 2450 22325 2450
-Wire Notes Line width 20
 	22325 2450 22325 8675
 Wire Notes Line width 20
-	22325 8675 18525 8675
-Wire Notes Line width 20
-	18525 8675 18525 2450
+	18375 8675 18375 2450
 Text Notes 19475 8375 0    150  Italic 30
 MCU and crystal
@@
 	18700 12075 18675 12075
 Connection ~ 9300 10475
-Connection ~ 9300 10375
-Wire Wire Line
-	9300 10375 9475 10375
-Wire Wire Line
-	9300 10375 9225 10375
 Wire Wire Line
 	9475 10475 9300 10475
@@
 Wire Wire Line
 	16000 8275 16075 8275
+$Comp
+L Device:C_Small CVA2
+U 1 1 5CFBDEE9
+P 18750 3900
+F 0 "CVA2" V 18650 3950 31  0000 R CNN
+F 1 "10n" H 18700 4000 31  0000 R CNN
+F 2 "Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder" H 18750 3900 50  0001 C CNN
+F 3 "~" H 18750 3900 50  0001 C CNN
+	1    18750 3900
+	-1   0    0    1
+$EndComp
+Wire Wire Line
+	18750 3700 18750 3800
+Wire Wire Line
+	18750 3700 19125 3700
+Connection ~ 19125 3700
+Wire Wire Line
+	19125 3700 19175 3700
+$Comp
+L power:GND #PWR0104
+U 1 1 5D036411
+P 18750 4100
+F 0 "#PWR0104" H 18750 3850 50  0001 C CNN
+F 1 "GND" V 18750 3925 50  0000 C CNN
+F 2 "" H 18750 4100 50  0001 C CNN
+F 3 "" H 18750 4100 50  0001 C CNN
+	1    18750 4100
+	1    0    0    -1
+$EndComp
+$Comp
+L Device:C_Small CVA1
+U 1 1 5D036CC3
+P 18550 3900
+F 0 "CVA1" V 18450 3950 31  0000 R CNN
+F 1 "1u" H 18675 3975 31  0000 R CNN
+F 2 "Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder" H 18550 3900 50  0001 C CNN
+F 3 "~" H 18550 3900 50  0001 C CNN
+	1    18550 3900
+	-1   0    0    1
+$EndComp
+Wire Wire Line
+	18550 3800 18550 3700
+Wire Wire Line
+	18550 3700 18750 3700
+Connection ~ 18750 3700
+Wire Wire Line
+	18750 4000 18750 4050
+Wire Wire Line
+	18750 4050 18550 4050
+Wire Wire Line
+	18550 4050 18550 4000
+Connection ~ 18750 4050
+Wire Wire Line
+	18750 4050 18750 4100
+Wire Notes Line width 20
+	18375 2450 22325 2450
+Wire Notes Line width 20
+	18375 8675 22325 8675
+$Comp
+L Power_Protection:USBLC6-2SC6 U3
+U 1 1 5D37D7BE
+P 15900 12650
+F 0 "U3" V 15550 13150 50  0000 L CNN
+F 1 "USBLC6-2SC6" V 15700 13100 50  0000 L CNN
+F 2 "Package_TO_SOT_SMD:SOT-23-6" H 15150 13050 50  0001 C CNN
+F 3 "http://www2.st.com/resource/en/datasheet/CD00050750.pdf" H 16100 13000 50  0001 C CNN
+	1    15900 12650
+	0    1    1    0
+$EndComp
+Text GLabel 15700 13200 0    50   BiDi ~ 0
+D+Bus
+Wire Wire Line
+	15700 13200 15800 13200
+$Comp
+L power:GND #PWR0105
+U 1 1 5D616544
+P 15300 12650
+F 0 "#PWR0105" H 15300 12400 50  0001 C CNN
+F 1 "GND" H 15250 12625 31  0000 C CNN
+F 2 "" H 15300 12650 50  0001 C CNN
+F 3 "" H 15300 12650 50  0001 C CNN
+	1    15300 12650
+	0    1    1    0
+$EndComp
+Wire Wire Line
+	15300 12650 15400 12650
+Wire Wire Line
+	15800 12075 15700 12075
+Text GLabel 15700 12075 0    50   BiDi ~ 0
+D-Bus
+$Comp
+L Device:C_Small CUSB1
+U 1 1 5D7F45E2
+P 16450 12850
+F 0 "CUSB1" V 16350 12900 31  0000 R CNN
+F 1 "4.7n" H 16575 12925 31  0000 R CNN
+F 2 "Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder" H 16450 12850 50  0001 C CNN
+F 3 "~" H 16450 12850 50  0001 C CNN
+	1    16450 12850
+	-1   0    0    1
+$EndComp
+$Comp
+L power:GND #PWR0106
+U 1 1 5D7F4E30
+P 16450 13050
+F 0 "#PWR0106" H 16450 12800 50  0001 C CNN
+F 1 "GND" H 16400 13025 31  0000 C CNN
+F 2 "" H 16450 13050 50  0001 C CNN
+F 3 "" H 16450 13050 50  0001 C CNN
+	1    16450 13050
+	1    0    0    -1
+$EndComp
+Wire Wire Line
+	16450 13050 16450 12950
+Wire Wire Line
+	16450 12750 16450 12650
+Wire Wire Line
+	16450 12650 16400 12650
+Wire Notes Line width 20
+	15100 11825 15100 13475
+Wire Notes Line width 20
+	17450 11825 17450 13475
+Text Notes 16550 13400 0    100  Italic 20
+Data ESD\nProtection
+Wire Notes Line width 20
+	15100 11825 17450 11825
+Wire Notes Line width 20
+	15100 13475 17450 13475
+Wire Wire Line
+	9300 10375 9225 10375
+Wire Wire Line
+	9225 10175 9300 10175
+Text GLabel 9400 10375 2    50   BiDi ~ 0
+D+Bus
+Text GLabel 9400 10175 2    50   BiDi ~ 0
+D-Bus
+Wire Wire Line
+	9300 10375 9400 10375
+Connection ~ 9300 10375
+Wire Wire Line
+	9300 10175 9400 10175
+Connection ~ 9300 10175
+Wire Wire Line
+	16050 13200 16000 13200
+$Comp
+L Device:R_Small RD-1
+U 1 1 5E5BA0B3
+P 16150 12075
+F 0 "RD-1" V 16075 12010 31  0000 L CNN
+F 1 "22R" V 16150 12025 31  0000 L CNN
+F 2 "Resistor_SMD:R_1206_3216Metric_Pad1.42x1.75mm_HandSolder" H 16150 12075 50  0001 C CNN
+F 3 "~" H 16150 12075 50  0001 C CNN
+	1    16150 12075
+	0    1    1    0
+$EndComp
+Wire Wire Line
+	16250 13200 16300 13200
+Wire Wire Line
+	16050 12075 16000 12075
+Wire Wire Line
+	16250 12075 16300 12075
+Wire Wire Line
+	15800 12075 15800 12150
+Wire Wire Line
+	16000 12075 16000 12150
+Wire Wire Line
+	15800 13200 15800 13150
+Wire Wire Line
+	16000 13200 16000 13150
 $EndSCHEMATC

Commit message: Updated footprints according to Acheron Library changes
Parts:
- removed J1: USB_C_Receptacle, USBconnector:TYPE-C-31-M-13, symbol shark-rescue:USB_C_Receptacle-Connector-shark-rescue-shark-rescue-shark-rescue
- removed U1: STM32F303CCT6, Package_QFP:LQFP-48_7x7mm_P0.5mm, symbol acheronSymbols:STM32F303CCT6
- added J1: TYPE-C-31-M12_13, acheronConnectors:TYPE-C-31-M-12, symbol acheronSymbols:TYPE-C-31-M12_13
- added U1: STM32F303-LQFP48, acheronComponents:LQFP-48_7x7mm_P0.5mm, symbol acheronSymbols:STM32F303-LQFP48
- U3: footprint Package_TO_SOT_SMD:SOT-23-6 -> acheronComponents:SOT-23-6
Connections:
- net 3.3V: now also U1.1 (VBAT), U1.24 (VCC), U1.36 (VCC), U1.48 (VCC), U1.9 (VCC/VDDA/VREF+)
- net BOOT0: now also U1.44 (BOOT0)
- net Col1: now also U1.2 (PC13)
- net Col10: now also U1.11 (PA1)
- net Col11: now also U1.25 (PB12)
- net Col12: now also U1.19 (PB1)
- net Col2: now also U1.3 (PC14/OSC32_IN)
- net Col3: now also U1.4 (PC15/OSC32_OUT)
- net Col4: now also U1.10 (PA0)
- net Col5: now also U1.12 (PA2)
- net Col6: now also U1.13 (PA3)
- net Col7: now also U1.14 (DAC1-OUT1/PA4)
- net Col8: now also U1.15 (DAC1-OUT2/PA5)
- net Col9: now also U1.16 (PA6)
- net D+Bus: now also J1.A6 (D+), J1.B6 (D+)
- net D-: now also U1.33 (PA12/USB_DP)
- net D-Bus: now also J1.A7 (D-), J1.B7 (D-)
- net EncA: now also U1.42 (I2C1_SCL/PB6)
- net EncB: now also U1.43 (I2C1_SDA/PB7)
- net Extra1: now also U1.29 (PA8)
- net Extra2: now also U1.28 (PB15)
- net Extra3: now also U1.27 (PB14)
- net Extra4: now also U1.26 (PB13)
- net Extra5: now also U1.39 (JTDO/TRACESWO/PB3)
- net Extra6: now also U1.41 (PB5)
- net Extra7: now also U1.45 (I2C1_SCL/PB8)
- net Extra8: now also U1.46 (I2C1_SDA/PB9)
- net GND: now also J1.A1 (GND), J1.B1 (GND), U1.23 (GND), U1.35 (GND), U1.47 (GND), U1.8 (GND/VSSA/VREF-)
- net LED_PWM: now also U1.22 (PB11)
- net NRST: now also U1.7 (NRST)
- net RGB_PWM: now also U1.17 (PA7)
- net Row1: now also U1.40 (JNTRST/PB4)
- net Row2: now also U1.38 (I2C1_SCL/JTDI/PA15)
- net Row3: now also U1.21 (PB10)
- net Row4: now also U1.20 (PB2)
- net SCL: now also U1.30 (I2C2_SCL/PA9)
- net SDA: now also U1.31 (I2C2_SDA/PA10)
- net SWCLK: now also U1.37 (PA14/SWCLK-JTCK/I2C1_SDA)
- net SWDIO: now also U1.34 (PA13/SWDIO-JTMS)
- net VBUS: now also CUSB1.2, U3.5 (VBUS), J1.A4 (VBUS), J1.B4 (VBUS)
- net XTAL1: now also U1.5 (PF0/OSC_IN/I2C2_SDA)
- net XTAL2: now also U1.6 (PF1/OSC_OUT/I2C2_SCL)
- net at C7.2, R5.1: now also J1.S (SHIELD)
- net at RCC1.2: now also J1.A5 (CC1), J1.B5 (CC2)
- no-connect marks 10 -> 2
Other:
- moved on the sheet: CVA1, CVA2, RCC1, RDPUp1
