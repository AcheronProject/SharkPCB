File: shark.kicad_pcb (KiCad board)
At the start: 2 copper layers, 226.2 x 78.2 mm, 234 parts, among them J101 USB_B_Mini, Q1 AO4406AL, SW1 MXSwitch, SW10 MXSwitch, SW11 MXSwitch, SW12 MXSwitch, SW13 MXSwitch, SW14 MXSwitch, SW15 MXSwitch, SW16 MXSwitch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

Commit message: Progressed with routing
Parts:
- Q1: footprint Keyboard_switches:SOIC-8 -> Keyboard_switches:AO4406AL
- moved RL48 172.4 mm to (245.2, 131.3), turned to 270 degrees
- moved RL36 168.5 mm to (253.2, 120.3)
- moved RL35 148.5 mm to (234.2, 120.6), turned to 180 degrees
- moved RL47 145.6 mm to (224.7, 121.8)
- moved RL24 144.1 mm to (245.2, 93.2), turned to 270 degrees
- moved RL46 141.8 mm to (215.1, 123.0)
- moved RL12 139.8 mm to (253.2, 82.2), turned to 180 degrees
- moved RL23 130.7 mm to (226.2, 93.2), turned to 270 degrees
- moved RL34 130.4 mm to (215.1, 120.6), turned to 180 degrees
- moved R1 130.1 mm to (75.5, 103.3), turned to 270 degrees
- moved RL11 119.4 mm to (234.2, 82.2), turned to 180 degrees
- moved RL44 117.4 mm to (186.6, 122.1), turned to 180 degrees
- moved RL22 113.9 mm to (220.5, 84.0)
- moved RL26 111.9 mm to (54.7, 112.3), turned to 270 degrees
- moved RL33 107.2 mm to (188.1, 112.3), turned to 270 degrees
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Connections:
- RPGate101 pad 2: Net-(Q1-Pad2) -> Net-(Q1-PadG)
- RSGate101 pad 1: Net-(Q1-Pad2) -> Net-(Q1-PadG)
Routing:
- net Net-(LED1-PadK): track 0.00 -> 1206.4 mm, vias 0 -> 1
- net LED_PWM: track 0.00 -> 114.0 mm
- net Row1: track 337.5 -> 266.9 mm
- net Row3: track 221.5 -> 259.4 mm
- net Net-(LED42-PadA): track 0.00 -> 28.8 mm
- net Net-(LED41-PadA): track 0.00 -> 27.6 mm
- net Col9: track 115.0 -> 142.2 mm
- net Net-(LED43-PadA): track 0.00 -> 26.9 mm
- net Row2: track 322.1 -> 345.5 mm
- net Col2: track 223.1 -> 245.5 mm
- net Net-(LED22-PadA): track 0.00 -> 22.1 mm
- net Net-(LED44-PadA): track 0.00 -> 21.3 mm
- net Net-(LED47-PadA): track 0.00 -> 18.3 mm
- net Net-(LED18-PadA): track 0.00 -> 17.9 mm
- net Net-(LED17-PadA): track 0.00 -> 17.4 mm
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Other:
- board text added: "Reset resistor"

Commit message: Finished routing
Parts:
- moved PSH1 164.6 mm to (234.2, 102.7)
- moved R1 152.4 mm to (227.9, 102.7)
- moved C7 2.84 mm to (235.7, 68.8), turned to 0 degrees
- moved R5 1.07 mm to (240.1, 68.8), turned to 0 degrees
- moved D30 0.60 mm to (147.3, 112.9)
- moved RL31 0.60 mm to (150.0, 112.9)
Connections:
- U1 pad 10: (no net) -> Row1
- U1 pad 30: (no net) -> Row2
- U1 pad 38: Row2 -> (no net)
- U1 pad 9: Row1 -> (no net)
Routing:
- net RST: track 152.8 -> 39.3 mm, vias 0 -> 2
- net Row2: track 345.5 -> 309.9 mm, vias 0 -> 1
- net VCC: track 36.0 -> 49.3 mm, vias 6 -> 5
- net GND: track 28.2 -> 15.6 mm, vias 2 -> 0
- net Net-(D6-Pad2): track 0.00 -> 9.34 mm
- net Row1: track 266.9 -> 261.9 mm
- net D-: track 16.3 -> 12.1 mm
- net Col2: track 245.5 -> 241.6 mm
- net Net-(C7-Pad2): track 16.1 -> 18.7 mm
- net (no net): track 0.00 -> 0.85 mm
- net Col3: track 208.2 -> 207.4 mm
- net Col5: track 166.5 -> 167.0 mm
Other:
- outline, holes or cut-outs redrawn
- board text added: "ESD protection"
- board text added: "RST"
- board text added: "RST PSHBTN"
- board text added: "Surge protection"
- board text removed: "Optional case EMD protection"
- board text removed: "Optional reset button"
- board text removed: "Optional reset resistor"
- board text removed: "Optional shield to GND"
- board text removed: "Optional surge protection"
- board text removed: "Reset resistor"

Commit message: Added logo
Parts:
- added L1: Logo, sharkLogo:sharkLogo, B.Cu at (171.1, 105.7)
- moved F1 0.60 mm to (226.0, 77.3)
- moved DS1 0.60 mm to (223.4, 77.3)
Routing:
- net Row1: track 261.9 -> 263.1 mm
- net VCC: track 49.3 -> 49.9 mm
Other:
- board text added: "RPG"
- board text added: "RSG"
- board text added: "SHIELD net"
- board text added: "XTAL"

Commit message: Added updated preview
Parts:
- added L1: Logo, sharkLogo:sharkLogo, F.Cu at (85.7, 105.7)

Commit message: Began porting to STM32
Parts:
- removed C3, C4, C5: 0.1u, Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
- removed C6: 4.7u, Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
- removed C8: 1u, Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
- removed J101: USB_B_Mini, Keyboard_switches:miniB_connector
- removed PSH1: SW_Push, Button_Switch_SMD:SW_SPST_SKQG_WithStem
- removed R1, R2, RPGate101: 10k, Resistor_SMD:R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
- removed R3, R4: 22, Resistor_SMD:R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
- removed RSGate101: 1k, Resistor_SMD:R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
- added CRST1: 4.7n, Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder, F.Cu at (170.7, 90.0)
- added CSRT2: 4.7n, Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder, F.Cu at (165.4, 83.7)
- added CSin1: 100n, Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder, B.Cu at (189.1, 107.2)
- added CSout1: 100n, Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder, B.Cu at (187.4, 101.3)
- added CVBus1: 100n, Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder, B.Cu at (182.4, 102.5)
- added CVBus2: 100n, Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder, B.Cu at (182.4, 104.6)
- added CVBus3: 100n, Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder, B.Cu at (182.4, 100.4)
- added CVBus4: 1u, Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder, B.Cu at (182.4, 106.7)
- added CVBus5: 4.7u, Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder, B.Cu at (182.4, 98.4)
- added DF1: RB060M-60TR, Diode_SMD:D_SOD-123, B.Cu at (222.1, 80.0)
- added DRST1: 1N4148, Diode_SMD:D_0805_2012Metric_Pad1.15x1.40mm_HandSolder, F.Cu at (168.7, 91.2)
- added J1: USB_C_Receptacle, USBconnector:TYPE-C-31-M-13, F.Cu at (223.9, 72.5)
- added QRST1: BC847, Package_TO_SOT_SMD:SOT-23, F.Cu at (167.5, 86.1)
- added RCC1: 5.1k, Resistor_SMD:R_1206_3216Metric_Pad1.42x1.75mm_HandSolder, F.Cu at (222.1, 76.9)
- added RD+1: 22R, Resistor_SMD:R_1206_3216Metric_Pad1.42x1.75mm_HandSolder, F.Cu at (179.0, 101.3)
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Connections:
- DS1 pad 1: VCC -> 5V
- DS1 pad 2: GND -> 3.3V
- F1 pad 1: VCC -> 5V
- F1 pad 2: Net-(F1-Pad2) -> VBUS
- RL1 pad 1: VCC -> 5V
- RL10 pad 1: VCC -> 5V
- RL11 pad 1: VCC -> 5V
- RL12 pad 1: VCC -> 5V
- RL13 pad 1: VCC -> 5V
- RL14 pad 1: VCC -> 5V
- RL15 pad 1: VCC -> 5V
- RL16 pad 1: VCC -> 5V
- RL17 pad 1: VCC -> 5V
- RL18 pad 1: VCC -> 5V
- RL19 pad 1: VCC -> 5V
- RL2 pad 1: VCC -> 5V
- RL20 pad 1: VCC -> 5V
- RL21 pad 1: VCC -> 5V
- RL22 pad 1: VCC -> 5V
- RL23 pad 1: VCC -> 5V
- RL24 pad 1: VCC -> 5V
- RL25 pad 1: VCC -> 5V
- RL26 pad 1: VCC -> 5V
- RL27 pad 1: VCC -> 5V
- RL28 pad 1: VCC -> 5V
- RL29 pad 1: VCC -> 5V
- RL3 pad 1: VCC -> 5V
- RL30 pad 1: VCC -> 5V
- RL31 pad 1: VCC -> 5V
- RL32 pad 1: VCC -> 5V
- RL33 pad 1: VCC -> 5V
- RL34 pad 1: VCC -> 5V
- RL35 pad 1: VCC -> 5V
- RL36 pad 1: VCC -> 5V
- RL37 pad 1: VCC -> 5V
- RL38 pad 1: VCC -> 5V
- RL39 pad 1: VCC -> 5V
- RL4 pad 1: VCC -> 5V
- RL40 pad 1: VCC -> 5V
- RL41 pad 1: VCC -> 5V
- RL42 pad 1: VCC -> 5V
- RL43 pad 1: VCC -> 5V
- RL44 pad 1: VCC -> 5V
- RL45 pad 1: VCC -> 5V
- RL46 pad 1: VCC -> 5V
- RL47 pad 1: VCC -> 5V
- RL48 pad 1: VCC -> 5V
- RL5 pad 1: VCC -> 5V
- RL6 pad 1: VCC -> 5V
- RL7 pad 1: VCC -> 5V
- RL8 pad 1: VCC -> 5V
- RL9 pad 1: VCC -> 5V
- U1 pad 1: (no net) -> 3.3V
- U1 pad 10: Row1 -> (no net)
- U1 pad 12: LED_PWM -> (no net)
- U1 pad 13: RST -> (no net)
- U1 pad 14: VCC -> (no net)
- U1 pad 15: GND -> (no net)
- U1 pad 16: XTAL2 -> (no net)
- U1 pad 17: XTAL1 -> (no net)
- U1 pad 18: Col8 -> (no net)
- U1 pad 19: Col7 -> (no net)
- U1 pad 2: VCC -> (no net)
- U1 pad 20: (no net) -> RGB_PWM
- U1 pad 21: Col1 -> (no net)
- U1 pad 22: Col2 -> (no net)
- U1 pad 24: VCC -> 3.3V
- U1 pad 26: Col3 -> (no net)
- U1 pad 27: Col4 -> (no net)
- U1 pad 28: Col5 -> (no net)
- U1 pad 29: Col6 -> (no net)
- U1 pad 3: Net-(R3-Pad1) -> (no net)
- U1 pad 30: Row2 -> (no net)
- U1 pad 32: Col9 -> D-
- U1 pad 33: Net-(R2-Pad2) -> D+
- U1 pad 34: VCC -> (no net)
- U1 pad 36: Row3 -> 3.3V
- U1 pad 37: Row4 -> (no net)
- U1 pad 39: Col10 -> (no net)
- U1 pad 4: Net-(R4-Pad1) -> (no net)
- U1 pad 41: (no net) -> LED_PWM
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Routing:
- net Net-(LED1-PadK): track 1206.4 -> 0.00 mm, vias 1 -> 0
- net Row4: track 357.8 -> 0.00 mm
- net Row2: track 309.9 -> 0.00 mm, vias 1 -> 0
- net Row1: track 263.1 -> 0.00 mm
- net Row3: track 259.4 -> 0.00 mm
- net Col1: track 251.2 -> 0.00 mm
- net Col2: track 241.6 -> 0.00 mm
- net Col3: track 206.9 -> 0.00 mm
- net Col4: track 188.2 -> 0.00 mm
- net Col6: track 171.6 -> 0.00 mm
- net Col5: track 167.2 -> 0.00 mm
- net Col7: track 153.4 -> 0.00 mm
- net Col9: track 142.2 -> 0.00 mm
- net 3.3V: track 0.00 -> 116.6 mm, vias 0 -> 6
- net LED_PWM: track 113.8 -> 1.59 mm, vias 0 -> 1
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- added copper zone on B.Cu, net 5V
- removed copper zone on B.Cu, net VCC
Other:
- board size 226.2 x 78.2 mm -> 225.6 x 75.4 mm
- net class Fine added: clearance 0.2, trace_width 0.13, via_dia 0.508, via_drill 0.2032
- board text added: "1S"
- board text added: "2S"
- board text added: "CRST"
- board text added: "CRST2"
- board text added: "CSI"
- board text added: "CSO"
- board text added: "DRST"
- board text added: "DS"
- board text added: "GondolinElectronics UndecidedSharkPCB v3.0 "I like the nick 'Shark', but I'm so undecided" Shark illustration by Yohan Plantec at vectorportal.com"
- board text added: "LDO"
- board text added: "PSHBTN"
- board text added: "QRST"
- board text added: "RCC"
- board text added: "RD+"
- board text added: "RD+Up"
- board text added: "RD-"
- board text added: "RRST"
- board text added: "STM32F303CCT6 (LQFP 48)"
- board text removed: "ATMEGA32U4 (TQFP 44)"
- board text removed: "GondolinElectronics UndecidedSharkPCB v2.0 "I like the nick 'Shark', but I'm so undecided" Shark illustration by Yohan Plantec at vectorportal.com"
- board text removed: "RST"
- board text removed: "RST PSHBTN"
- board text removed: "SHIELD net"

Commit message: Solved issues with connector via placement
Parts:
- moved F1 2.07 mm to (225.0, 77.4), turned to 90 degrees
- moved H11 0.25 mm to (243.5, 121.7)
- moved H8 0.25 mm to (53.5, 83.7)
- moved H2 0.25 mm to (53.5, 102.7)
- moved H9 0.25 mm to (53.5, 121.8)
- moved H6 0.16 mm to (205.5, 121.7)
- moved H4 0.16 mm to (205.5, 83.7)
- moved H3 0.16 mm to (91.5, 121.7)
- moved H1 0.16 mm to (91.5, 83.7)
Routing:
- net Net-(J1-PadA7): track 21.8 -> 13.8 mm
- net VBUS: track 9.27 -> 12.7 mm, vias 0 -> 2
